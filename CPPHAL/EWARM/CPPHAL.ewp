# IAR project CPPHAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433RC ST STM32L433RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: CPPHAL.out
  ILINK.IlinkIcfFile: CPPHAL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group (top)
    ../Src/: main.cpp
    ./: startup_stm32l433xx.s
  group bsl/include
    ../bsl/include/: Led.h Switch.h
  group csl/include
    ../csl/include/: bits.h HwReg.h Pin.h Port.h RCC.h
  group csl/src
    ../csl/src/: periMemMap.h Pin.cpp Port.cpp RCC.cpp
