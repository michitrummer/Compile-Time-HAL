# IAR project CHAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433RC ST STM32L433RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CHAL.srec
  ILINK.IlinkOutputFile: CHAL.out
  ILINK.IlinkIcfFile: CHAL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group (top)
    ../Src/: main.c
    ./: startup_stm32l433xx.s
  group bsl/include
    ../bsl/include/: led.h switch.h
  group csl/include
    ../csl/include/: bits.h hwReg.h pin.h port.h rcc.h
  group csl/src
    ../csl/src/: periMemMap.h pin.c port.c rcc.c
